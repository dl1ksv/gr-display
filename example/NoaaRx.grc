<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NoaaRx</value></param>
<param><key>title</key><value>WxSatRx</value></param>
<param><key>author</key><value>DL1KSV</value></param>
<param><key>description</key><value>Receive  and display Noaa Images</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate/2</value></param>
<param><key>device_name</key><value>LinPSK_Play</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_skiphead</key>
<param><key>id</key><value>gr_skiphead_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_float_to_complex</key>
<param><key>id</key><value>gr_float_to_complex_1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_float_to_uchar</key>
<param><key>id</key><value>gr_float_to_uchar_0</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>Start</value></param>
<param><key>type</key><value>float</value></param>
<param><key>open</key><value>StartDisplay</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>48000</value></param>
<param><key>interp</key><value>9600</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>255</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>Volume</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Rx</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>label1</key><value>Image</value></param>
</block>
<block>
<key>display_show_image</key>
<param><key>id</key><value>display_show_image_0</value></param>
<param><key>imagewidth</key><value>2080</value></param>
<param><key>imageheight</key><value>1500</value></param>
<param><key>gui_hint</key><value>Rx@1</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>4800</value></param>
<param><key>interp</key><value>4160</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/2</value></param>
<param><key>low_cutoff_freq</key><value>2100</value></param>
<param><key>high_cutoff_freq</key><value>2800</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>gr_complex_to_float</key>
<param><key>id</key><value>gr_complex_to_float_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>StartDisplay</value></param>
<param><key>label</key><value>Start Displaing</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>label0</key><value>Stop</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>label1</key><value>Start</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>gui_hint</key><value>Rx@0:2,2,1,1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>open</key><value>StartRecord</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>StartRecord</value></param>
<param><key>label</key><value>Start Recording</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>label0</key><value>Stop</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>label1</key><value>Start</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>gui_hint</key><value>Rx@1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RxOffset</value></param>
<param><key>value</key><value>-10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>LNA</value></param>
<param><key>label</key><value>LNA Gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>start</key><value>-5</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>step</key><value>2.5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>Rx@0:2,0,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>MIXER</value></param>
<param><key>label</key><value>Mixer Gain</value></param>
<param><key>value</key><value>12</value></param>
<param><key>start</key><value>4</value></param>
<param><key>stop</key><value>12</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>Rx@0:2,1,1,1</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>1000*RxOffset</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Fine</value></param>
<param><key>label</key><value>Fine Tuning Filter</value></param>
<param><key>value</key><value>39000</value></param>
<param><key>start</key><value>36000</value></param>
<param><key>stop</key><value>42000</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>Rx@0:4,0,1,1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>Fine</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>fcd_source_c</key>
<param><key>id</key><value>fcd_source_c_0</value></param>
<param><key>device_name</key><value>FCD</value></param>
<param><key>freq</key><value>sat+FineRx+RxOffset*1000</value></param>
<param><key>lna</key><value>LNA</value></param>
<param><key>mixer</key><value>MIXER</value></param>
<param><key>ppm</key><value>-120</value></param>
<param><key>dci</key><value>0.0</value></param>
<param><key>dcq</key><value>0.0</value></param>
<param><key>iq_phase</key><value>0.0</value></param>
<param><key>iq_gain</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>sat</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>value</key><value>137620000</value></param>
<param><key>option0</key><value>137620000</value></param>
<param><key>label0</key><value>Noaa15</value></param>
<param><key>option1</key><value>137500000</value></param>
<param><key>label1</key><value>Noaa17</value></param>
<param><key>option2</key><value>137912500</value></param>
<param><key>label2</key><value>Noaa18</value></param>
<param><key>option3</key><value>137100000</value></param>
<param><key>label3</key><value>Noaa19</value></param>
<param><key>gui_hint</key><value>Rx@0:0,0,1,1</value></param>
</block>
<block>
<key>gr_wavfile_sink</key>
<param><key>id</key><value>gr_wavfile_sink_0</value></param>
<param><key>file</key><value>/tmp/noaa.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>FineRx</value></param>
<param><key>label</key><value>Fine Tuning Rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-2000</value></param>
<param><key>stop</key><value>2000</value></param>
<param><key>step</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>Rx@0:4,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Volume</value></param>
<param><key>value</key><value>25</value></param>
<param><key>start</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>Rx@1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>sat</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>gui_hint</key><value>Rx@0:6,0,2,3</value></param>
</block>
<block>
<key>blks2_wfm_rcv</key>
<param><key>id</key><value>blks2_wfm_rcv_0</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
<param><key>audio_decimation</key><value>2</value></param>
</block>
<connection><source_block_id>blks2_wfm_rcv_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>gr_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_skiphead_0</source_block_id><sink_block_id>gr_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>gr_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>gr_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_1</source_block_id><sink_block_id>gr_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_float_to_complex_1</source_block_id><sink_block_id>gr_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_float_to_uchar_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_float_to_uchar_0</source_block_id><sink_block_id>display_show_image_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0</source_block_id><sink_block_id>Start</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Start</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blks2_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_float_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_float_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fcd_source_c_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>gr_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fcd_source_c_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_1</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
