options:
  parameters:
    author: dl1ksv
    generate_options: qt_gui
    id: Messagetext
    output_language: python
    title: Test a test message
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '3000'
  states: {}
- name: display_text_msg_0
  id: display_text_msg
  parameters:
    label: ' "Text message"'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, display_text_msg_0, text]

metadata:
  file_format: 1
