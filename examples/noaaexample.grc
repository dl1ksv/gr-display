<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>FCDPROTest</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Rx</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>Spectrum and Control</value></param>
<param><key>label1</key><value>Image</value></param>
<param><key>gui_hint</key><value>1,0,5,6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Force</value></param>
<param><key>label</key><value>Force Display</value></param>
<param><key>type</key><value>real</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>Automatic start</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>Force start</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Lna</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>Off</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>On</value></param>
<param><key>gui_hint</key><value>Rx@0:0,3,1,1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Mixergain</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>Off</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>On</value></param>
<param><key>gui_hint</key><value>Rx@0:0,4,1,1</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>show_image</key>
<param><key>id</key><value>show_image_0</value></param>
<param><key>imagewidth</key><value>2080</value></param>
<param><key>imageheight</key><value>1400</value></param>
<param><key>gui_hint</key><value>Rx@1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>Start_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>open</key><value>StartRecord</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>delay</key><value>30</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_2</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>(-14,-14,-14,-14,-14,-14,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,-14)</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1./25500.</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>Force</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ifgain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>59</value></param>
<param><key>step</key><value>1</value></param>
<param><key>widget</key><value>counter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>80</value></param>
<param><key>gui_hint</key><value>Rx@0:0,2,1,1</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0</value></param>
<param><key>low</key><value>20000</value></param>
<param><key>high</key><value>30000</value></param>
<param><key>init</key><value>0</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_1_0</value></param>
<param><key>low</key><value>-1</value></param>
<param><key>high</key><value>0.9</value></param>
<param><key>init</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>StartRecord</value></param>
<param><key>label</key><value>Start Recording</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>label0</key><value>Stop</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>label1</key><value>Start</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>file</key><value>/tmp/Noaa.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>fcdproplus_fcdproplus</key>
<param><key>id</key><value>fcdproplus_fcdproplus_1</value></param>
<param><key>device_name</key><value></value></param>
<param><key>unit</key><value>1000</value></param>
<param><key>lnaswitch</key><value>Lna</value></param>
<param><key>mixergainswitch</key><value>Mixergain</value></param>
<param><key>freq</key><value>(sat-20)</value></param>
<param><key>ppm</key><value>0</value></param>
<param><key>if_gain</key><value>int(Ifgain)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>RxFrequency</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>decodeApt</key>
<param><key>id</key><value>decodeApt_0</value></param>
<param><key>gain</key><value>255</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>Rx@0</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>2080</value></param>
<param><key>srate</key><value>samp_rate/10</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>-2</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>gui_hint</key><value>Rx@0</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RxFrequency</value></param>
<param><key>label</key><value>Set Frequency Offset</value></param>
<param><key>value</key><value>-8000</value></param>
<param><key>start</key><value>-50000</value></param>
<param><key>stop</key><value>0</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>widget</key><value>counter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>130</value></param>
<param><key>gui_hint</key><value>Rx@0:0,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>sat</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>value</key><value>137620</value></param>
<param><key>option0</key><value>137620</value></param>
<param><key>label0</key><value>Noaa15</value></param>
<param><key>option1</key><value>137500</value></param>
<param><key>label1</key><value>Noaa17</value></param>
<param><key>option2</key><value>137912</value></param>
<param><key>label2</key><value>Noaa18</value></param>
<param><key>option3</key><value>137100</value></param>
<param><key>label3</key><value>Noaa19</value></param>
<param><key>gui_hint</key><value>Rx@0:0,0,1,1</value></param>
</block>
<connection><source_block_id>Start_1</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_2</source_block_id><sink_block_id>blocks_threshold_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_1_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>show_image_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>show_image_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fcdproplus_fcdproplus_1</source_block_id><sink_block_id>Start_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decodeApt_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decodeApt_0</source_block_id><sink_block_id>fir_filter_xxx_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_threshold_ff_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fcdproplus_fcdproplus_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>decodeApt_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
