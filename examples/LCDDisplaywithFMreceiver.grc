options:
  parameters:
    author: dl1ksv
    category: Custom
    generate_options: qt_gui
    id: FMRadio
    output_language: python
    title: FM radio to test FCDPROplus
  states: {}

blocks:
- name: Ifgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: IFGain
    min_len: '45'
    rangeType: int
    start: '0'
    step: '1'
    stop: '59'
    value: '10'
    widget: counter
  states: {}
- name: Lna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: LNA Enable/Disable
    label0: 'On'
    label1: 'Off'
    num_opts: '2'
    option0: '1'
    option1: '0'
    type: int
    value: '1'
  states: {}
- name: Mixergain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label0: 'On'
    label1: 'Off'
    num_opts: '2'
    option0: '1'
    option1: '0'
    type: int
    value: '1'
  states: {}
- name: StartFrequency
  id: variable
  parameters:
    value: '88800000'
  states: {}
- name: qtgui_msgdigitalnumbercontrol_0
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,0,1,1
    lbl: Tuning
    maxFreqHz: 120e6
    minFreqHz: 80e6
    value: StartFrequency
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: funcube_fcdpp_0
  id: funcube_fcdpp
  parameters:
    freq: StartFrequency
    if_gain: Ifgain
    lnaswitch: Lna
    mixergainswitch: Mixergain
    ppm: '0'
    unit: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60000'
    decim: '1'
    gain: '5'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: StartFrequency
    fftsize: '1024'
    gui_hint: 1,0,1,7
    name: QT GUI Plot
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [analog_fm_deemph_0, '0', audio_sink_0, '1']
- [analog_fm_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [funcube_fcdpp_0, '0', low_pass_filter_0, '0']
- [funcube_fcdpp_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [qtgui_msgdigitalnumbercontrol_0, valueout, funcube_fcdpp_0, freq]
- [qtgui_msgdigitalnumbercontrol_0, valueout, qtgui_sink_x_0, freq]
- [qtgui_sink_x_0, freq, qtgui_msgdigitalnumbercontrol_0, valuein]

metadata:
  file_format: 1
