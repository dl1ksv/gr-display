options:
  parameters:
    author: dl1ksv
    copyright: dl1ksv
    generate_options: qt_gui
    id: lcdtest
    output_language: python
    title: Flowgraph for testing the lcd_display
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:0,0
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: display_lcd_display_0
  id: display_lcd_display
  parameters:
    gui_hint: ':6,0,1,1'
    max_value: '100000'
    min_step: '1'
    min_value: '-10000'
    num_digits: '6'
    unit_type: '0'
    value: '1000'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: ':0,0,5,2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0, '0']
- [analog_sig_source_x_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [display_lcd_display_0, freq, analog_sig_source_x_0, freq]
- [display_lcd_display_0, freq, blocks_message_debug_0, print]
- [qtgui_waterfall_sink_x_0, freq, display_lcd_display_0, freq]

metadata:
  file_format: 1
