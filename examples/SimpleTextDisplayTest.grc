options:
  parameters:
    author: dl1ksv
    generate_options: qt_gui
    id: displayTest
    output_language: python
    title: Simple Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: ([i+32 for i in range(64)] )
  states: {}
- name: show_text_0
  id: show_text
  parameters:
    label: Test
  states: {}

connections:
- [blocks_throttle_0, '0', show_text_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
