options:
  parameters:
    author: dl1ksv
    generate_options: qt_gui
    id: display_text
    output_language: python
    title: Display text in a window
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: 3*list("Gutta cavat lapidem non vi sed saepe cadendo\n0123456789\n\n".encode())
  states: {}
- name: show_text_0
  id: show_text
  parameters:
    label: Text Display
    maxlines: '100'
    splitlength: '40'
  states: {}

connections:
- [blocks_throttle_0, '0', show_text_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11-compat-xxx-xunknown
